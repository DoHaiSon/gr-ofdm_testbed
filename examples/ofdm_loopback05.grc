options:
  parameters:
    category: Custom
    description: Transmit a pre-defined signal (a complex sine) as OFDM packets.
    generate_options: qt_gui
    id: ofdm_loopback_example
    output_language: python
    title: OFDM Loopback Example
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset (Multiples of Sub-carrier spacing)
    start: '-3'
    step: '.01'
    stop: '3'
    value: '0'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: rf_rate
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/minh/output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/minh/intput.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '275'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Packets
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ()
    type: byte
    vector: range(packet_len)
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '128'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"BPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: ofdm_testbed_image_vector_source_0
  id: ofdm_testbed_image_vector_source
  parameters:
    channel_coding: '1'
    filename: /home/minh/tải xuống.png
    image_size: 224*225
    packet_size: '1024'
    repeat: 'False'
    tags: '[]'
    vlen: '1'
  states: {state: disabled}
- name: ofdm_testbed_image_vector_source_0_0
  id: ofdm_testbed_image_vector_source
  parameters:
    channel_coding: '0'
    filename: /home/minh/tải xuống.png
    image_size: 224*225
    packet_size: '1024'
    repeat: 'True'
    tags: '[]'
    vlen: '1'
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=2a40,buffers=128,buflen=32768
    bb_gain0: '20'
    bw0: '1500000'
    freq0: 2.4e9
    gain0: '60'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=2a40,buffers=128,buflen=32768
    bb_gain0: '20'
    bw0: 1.5e6
    dc_offset_mode0: '1'
    freq0: 2.4e9
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '1'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum1
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: Scope Plot Output
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: Receiver Output
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: Transmitter Input
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: show_image_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    gui_hint: 'tab_0@1: 0,0,1,1'
    imageheight: '512'
    imagewidth: '512'
  states: {state: disabled}
- name: show_text_0
  id: show_text
  parameters:
    label: ''
    maxlines: '100'
    splitlength: '0'
  states: {}
- name: tab_0
  id: qtgui_tab_widget
  parameters:
    label0: QT GUI
    label1: Demodulation
    num_tabs: '2'
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_float_0_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', osmosdr_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [dc_blocker_xx_0, '0', blocks_complex_to_float_0, '0']
- [dc_blocker_xx_0, '0', digital_ofdm_rx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_ofdm_rx_0, '0', blocks_file_sink_0, '0']
- [digital_ofdm_rx_0, '0', blocks_head_0, '0']
- [digital_ofdm_rx_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_rx_0, '0', show_image_0, '1']
- [digital_ofdm_rx_0, '0', show_text_0, '0']
- [digital_ofdm_tx_0, '0', blocks_complex_to_float_0_1, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_ofdm_tx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [ofdm_testbed_image_vector_source_0, '0', blocks_throttle_0, '0']
- [ofdm_testbed_image_vector_source_0_0, '0', blocks_throttle_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
