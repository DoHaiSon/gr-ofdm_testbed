options:
  parameters:
    author: Do Hai Son
    comment: BER test with regenerate capability
    generate_options: qt_gui
    id: test_BER
    output_language: python
    title: Test BER block
  states: {}

blocks:
- name: avg_len
  id: variable
  parameters:
    comment: Fixed averaging window
    value: '100000'
  states: {}
- name: ber_percent
  id: variable_qtgui_range
  parameters:
    comment: BER from 0.001% to 100%
    gui_hint: 0,0,1,1
    label: Expected BER (%)
    start: '0.00001'
    step: '0.00001'
    stop: '1'
    value: '0.01'
  states: {}
- name: pattern_len
  id: variable
  parameters:
    comment: Length of pattern to generate
    value: '50000'
  states: {}
- name: regenerate_trigger
  id: variable_qtgui_push_button
  parameters:
    comment: Button to regenerate pattern
    gui_hint: 1,0,1,1
    label: Regenerate Pattern
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Control data rate
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import random

      class blk(gr.sync_block):
          """Generate reference and received bits with variable error rate"""

          def __init__(self, error_rate=0.10, pattern_len=50000, regen_trigger=0):
              gr.sync_block.__init__(
                  self,
                  name='BER Pattern Generator',
                  in_sig=None,
                  out_sig=[np.uint8, np.uint8]  # ref and rx outputs
              )
              self.error_rate = error_rate
              self.pattern_len = pattern_len
              self.index = 0
              self.last_trigger = regen_trigger
              self.need_regen = False
              
              # Generate initial pattern
              self.regenerate_pattern()
          
          def regenerate_pattern(self):
              """Generate new reference and received patterns"""
              random.seed()  # Use current time as seed
              
              # Generate random reference bits
              self.ref_bits = [random.randint(0, 1) for _ in range(self.pattern_len)]
              
              # Generate received bits with errors
              self.rx_bits = []
              for bit in self.ref_bits:
                  if random.random() < self.error_rate:
                      # Inject error
                      self.rx_bits.append(1 - bit)
                  else:
                      # No error
                      self.rx_bits.append(bit)
              
              self.index = 0
              self.need_regen = False
              print(f"Generated {self.pattern_len} bits with {self.error_rate*100:.3f}% error rate")
          
          def set_error_rate(self, error_rate):
              """Update error rate and mark for regeneration"""
              if abs(self.error_rate - error_rate) > 0.0001:  # Only regenerate if significant change
                  self.error_rate = error_rate
                  self.need_regen = True
          
          def set_regen_trigger(self, trigger):
              """Trigger pattern regeneration when button is pressed"""
              if trigger == 1 and self.last_trigger == 0:  # Detect press (0->1 transition)
                  print("\nButton pressed - marking for regeneration...")
                  self.need_regen = True
              self.last_trigger = trigger

          def work(self, input_items, output_items):
              # Check if we need to regenerate before producing output
              if self.need_regen:
                  print("Regenerating pattern in work()...")
                  self.regenerate_pattern()
              
              out_ref = output_items[0]
              out_rx = output_items[1]
              
              for i in range(len(out_ref)):
                  out_ref[i] = self.ref_bits[self.index]
                  out_rx[i] = self.rx_bits[self.index]
                  self.index = (self.index + 1) % self.pattern_len
              
              return len(out_ref)
    comment: Generates synchronized ref and rx bits
    error_rate: ber_percent / 100.0
    pattern_len: pattern_len
    regen_trigger: regenerate_trigger
  states: {}
- name: import_random
  id: import
  parameters:
    imports: import random
  states: {}
- name: ofdm_testbed_ber_0
  id: ofdm_testbed_ber
  parameters:
    avg_len: avg_len
    enable_output: 'True'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    factor1: '100'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,0,1,1
    label1: Measured BER
    max: '100'
    min: '0'
    name: '"Current BER"'
    type: float
    unit1: '%'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,3,1
    label1: Measured BER
    name: '"BER vs Time"'
    size: '10000'
    srate: samp_rate
    type: float
    width1: '2'
    ylabel: BER
    ymin: '0'
  states: {}

connections:
- [blocks_throttle_0, '0', ofdm_testbed_ber_0, '0']
- [epy_block_0, '0', blocks_throttle_0, '0']
- [epy_block_0, '1', ofdm_testbed_ber_0, '1']
- [ofdm_testbed_ber_0, '0', qtgui_number_sink_0, '0']
- [ofdm_testbed_ber_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
