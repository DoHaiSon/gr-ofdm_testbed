options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: ofdm
    output_language: python
    title: ofdm_simulation
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: rf_rate
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: blocks_complex_to_float_0_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\haimi\Downloads\GNUradio\sink.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\haimi\Downloads\GNUradio\source.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '69'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Packets
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"QPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"8-PSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"QPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"8-PSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum1
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: Scope Plot Output
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: Transmitter Input
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_complex_to_float_0_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_ofdm_rx_0, '0', blocks_head_0, '0']
- [digital_ofdm_rx_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_tx_0, '0', blocks_complex_to_float_0_1, '0']
- [digital_ofdm_tx_0, '0', digital_ofdm_rx_0, '0']
- [digital_ofdm_tx_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
