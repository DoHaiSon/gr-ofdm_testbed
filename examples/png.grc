options:
  parameters:
    generate_options: qt_gui
    id: png
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: ofdm_testbed_image_vector_source_0
  id: ofdm_testbed_image_vector_source
  parameters:
    channel_coding: '0'
    filename: /home/minh/SDR_NC/2 Nodes/2_P2P_Img/lena_gray_512.txt
    image_size: 512*512
    packet_size: '1024'
    repeat: 'True'
    tags: '[]'
    vlen: '1'
  states: {}
- name: show_image_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    imageheight: '512'
    imagewidth: '512'
  states: {}

connections:
- [ofdm_testbed_image_vector_source_0, '0', show_image_0, '0']
- [ofdm_testbed_image_vector_source_0, '0', show_image_0, '1']

metadata:
  file_format: 1
