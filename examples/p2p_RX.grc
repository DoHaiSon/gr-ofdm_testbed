options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    const_points: '[-1+1j, 1+1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: cp_length
  id: variable
  parameters:
    value: '16'
  states: {}
- name: data_block_rep
  id: variable
  parameters:
    value: '1'
  states: {}
- name: data_block_sz
  id: variable
  parameters:
    value: '21'
  states: {}
- name: data_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: occupied_tones
  id: variable
  parameters:
    value: '48'
  states: {}
- name: pilot_block_rep
  id: variable
  parameters:
    value: '1'
  states: {}
- name: preamble_block_rep
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.5e6
  states: {}
- name: silence_block_rep
  id: variable
  parameters:
    value: '1'
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 25e3
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
  states: {state: disabled}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '256'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"BPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: ofdm_testbed_byte_to_bit_0
  id: ofdm_testbed_byte_to_bit
  parameters: {}
  states: {}
- name: ofdm_testbed_receiver_control_p2p_0
  id: ofdm_testbed_receiver_control_p2p
  parameters:
    packet_size: '1024'
    receiver_id: '170'
    transmitter_id: '187'
  states: {}
- name: ofdm_testbed_zero_elimination_0
  id: ofdm_testbed_zero_elimination
  parameters:
    data_len: '1024'
    node_id: '170'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tab_0@0: 0,0,1,1'
    showports: 'True'
    type: complex
  states: {}
- name: show_image_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    gui_hint: 'tab_0@1: 0,0,1,1'
    imageheight: '512'
    imagewidth: '512'
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: 2.415e9
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    center_freq: 2.45e9
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: tab_0
  id: qtgui_tab_widget
  parameters:
    label0: QT GUI
    label1: Demodulation
    num_tabs: '2'
  states: {}

connections:
- [blocks_multiply_const_vxx_0_0_0, '0', digital_ofdm_rx_0_0, '0']
- [dc_blocker_xx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [digital_ofdm_rx_0_0, '0', ofdm_testbed_receiver_control_p2p_0, '0']
- [digital_ofdm_tx_0, '0', soapy_bladerf_sink_0, '0']
- [ofdm_testbed_byte_to_bit_0, '0', digital_ofdm_tx_0, '0']
- [ofdm_testbed_receiver_control_p2p_0, '0', ofdm_testbed_byte_to_bit_0, '0']
- [ofdm_testbed_receiver_control_p2p_0, '1', ofdm_testbed_zero_elimination_0, '0']
- [ofdm_testbed_zero_elimination_0, '0', show_image_0, '0']
- [ofdm_testbed_zero_elimination_0, '0', show_image_0, '1']
- [soapy_bladerf_source_0, '0', dc_blocker_xx_0_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
