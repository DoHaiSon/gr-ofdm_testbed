options:
  parameters:
    generate_options: qt_gui
    id: p2p
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: band_width
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    const_points: '[-1+1j, 1+1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {state: disabled}
- name: cp_length
  id: variable
  parameters:
    value: '16'
  states: {}
- name: data_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: occupied_tones
  id: variable
  parameters:
    value: '48'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.2e6
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 25e3
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '6'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Packets
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_0
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {state: disabled}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '128'
    long_form: 'True'
    type: cc
  states: {}
- name: dc_blocker_xx_0_0_0
  id: dc_blocker_xx
  parameters:
    length: '256'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"BPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_tx_0_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: ofdm_testbed_byte_to_bit_0_0
  id: ofdm_testbed_byte_to_bit
  parameters: {}
  states: {state: disabled}
- name: ofdm_testbed_image_vector_source_0
  id: ofdm_testbed_image_vector_source
  parameters:
    channel_coding: '0'
    filename: /home/minh/SDR_NC/2 Nodes/2_P2P_Img/lena_gray_512.txt
    image_size: 512*512
    packet_size: '1024'
    repeat: 'False'
    tags: '[]'
    vlen: '1'
  states: {state: disabled}
- name: ofdm_testbed_primary_tx_control_0
  id: ofdm_testbed_primary_tx_control
  parameters:
    ack_burst_size: '6'
    destination_id: '170'
    guard_interval: '6'
    packet_sz: '1024'
    source_id: '187'
  states: {state: disabled}
- name: ofdm_testbed_receiver_control_p2p_0
  id: ofdm_testbed_receiver_control_p2p
  parameters:
    packet_size: '1024'
    receiver_id: '170'
    transmitter_id: '187'
  states: {}
- name: ofdm_testbed_zero_elimination_0
  id: ofdm_testbed_zero_elimination
  parameters:
    data_len: '1024'
    node_id: '170'
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: bladerf=2a40,buffers=256,buflen=65536
    bb_gain0: '20'
    bw0: band_width
    freq0: 2.4e9
    gain0: '60'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=2a40,buffers=256,buflen=65536
    bb_gain0: '20'
    bw0: band_width
    dc_offset_mode0: '1'
    freq0: 2.415e9
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '1'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_0
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 2.5e6
    fc: '0'
    fftsize: '1024'
    gui_hint: 'tab_0@0: 0,0,1,1'
    showports: 'True'
    type: complex
  states: {}
- name: show_image_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    gui_hint: 'tab_0@1: 0,0,1,1'
    imageheight: '512'
    imagewidth: '512'
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: 1.5e6
    center_freq: 2.55e9
    dev_args: serial=ca4c
    gain: '50.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_sink_0_0
  id: soapy_bladerf_sink
  parameters:
    bandwidth: 1.5e6
    center_freq: 2.45e9
    dev_args: bladerf=2a40
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_0_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: '1500000'
    center_freq: 2.415e9
    dev_args: bladerf=2a40
    gain: '20'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: tab_0
  id: qtgui_tab_widget
  parameters:
    label0: QT GUI
    label1: Demodulation
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: 2a40
  states: {state: disabled}

connections:
- [blocks_interleaved_char_to_complex_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', osmosdr_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', digital_ofdm_rx_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0_0_0, '0']
- [blocks_stream_to_vector_2, '0', ofdm_testbed_primary_tx_control_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', dc_blocker_xx_0_0_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [dc_blocker_xx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [dc_blocker_xx_0_0, '0', digital_ofdm_rx_0_0, '0']
- [dc_blocker_xx_0_0, '0', qtgui_sink_x_0, '0']
- [dc_blocker_xx_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [digital_ofdm_rx_0, '0', blocks_stream_to_vector_2, '0']
- [digital_ofdm_rx_0_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0_0, '0', ofdm_testbed_receiver_control_p2p_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_throttle_0, '0']
- [digital_ofdm_tx_0_0, '0', soapy_bladerf_sink_0_0, '0']
- [digital_ofdm_tx_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [ofdm_testbed_byte_to_bit_0_0, '0', digital_ofdm_tx_0_0, '0']
- [ofdm_testbed_image_vector_source_0, '0', ofdm_testbed_primary_tx_control_0, '1']
- [ofdm_testbed_primary_tx_control_0, '0', ofdm_testbed_byte_to_bit_0_0, '0']
- [ofdm_testbed_receiver_control_p2p_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [ofdm_testbed_receiver_control_p2p_0, '0', blocks_repack_bits_bb_0, '0']
- [ofdm_testbed_receiver_control_p2p_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [ofdm_testbed_receiver_control_p2p_0, '1', ofdm_testbed_zero_elimination_0, '0']
- [ofdm_testbed_zero_elimination_0, '0', show_image_0, '0']
- [ofdm_testbed_zero_elimination_0, '0', show_image_0, '1']
- [osmosdr_source_0, '0', dc_blocker_xx_0_0, '0']
- [soapy_bladerf_source_0_0, '0', dc_blocker_xx_0_0_0, '0']

metadata:
  file_format: 1
